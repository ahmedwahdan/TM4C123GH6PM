<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Keypad_Layered\keypad_layered.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SPI\SPI.ewp</path>
  </project>
  <batchBuild/>
</workspace>


